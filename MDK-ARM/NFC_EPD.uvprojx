# Keil uVision project NFC_EPD.uvprojx, settings and files
target EPD_2IN13D (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: NFC_EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L011xx,EPD_2IN13D
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Application/MDK-ARM
    ./: startup_stm32l011xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c DEV_Config.c EPD_2in9b_V3.c EPD_2in13b_V3.c EPD_2in13bc.c EPD_2in13d.c EPD_HINK.c EPD_WF0213T1PCZ04.c EPD_SSD1680.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
target EPD_WF0213T1PCZ04 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: NFC_EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L011xx,EPD_WF0213T1PCZ04
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
target EPD_HINK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: NFC_EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L011xx,EPD_HINK
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
target EPD_2IN9B_V3 (6220000::V6.22::ARMCLANG)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: NFC_EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L011xx,EPD_2IN9B_V3
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
target EPD_SSD1680 (6220000::V6.22::ARMCLANG)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: NFC_EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L011xx,EPD_SSD1680
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
software components: CMSIS:CORE 6.1.0
